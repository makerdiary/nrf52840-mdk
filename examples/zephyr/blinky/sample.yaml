## examples/zephyr/blinky/sample.yaml
```yaml
sample:
  name: Blinky Sample
tests:
  test:
    platform_whitelist: nrf52840_mdk
    tags: samples
    depends_on: gpio
```
